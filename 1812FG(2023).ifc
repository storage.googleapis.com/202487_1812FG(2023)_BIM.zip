Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-10T15:53:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 10 15:53:58 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{80D52E10-B5AC-4462-9DBA-84A40410DB2C}\ifc * Database version: 5507 * Database creation date: Mon Jun 10 15:53:57 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 10 15:53:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 10 15:53:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1812FG Washbasin faucet, 1812FG(2018):1812FG Washbasin faucet:331576
In: Level 1
Type - PredefinedType: FAUCET; Material: Copper
Type - Dimensions(Type) - FaucetNominalDepth: 144.5 mm; FaucetNominalHeight: 151 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 286.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm; Projection: 107 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1812FG(2018); ConvergoRefNr: 0087-1906-0010-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 06/06/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150089404; EN Standard: EN 817; LVI Number: 6110257; Noise Class: I (ISO 3822); RSK Number: 8278056
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1812FG; Catalog Drawing URL: http://static.oras.com/catdrw/1812FG; Class: Single lever, Bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/1812FG; FDV Document URL: http://www.oras.com/datasheet/1812FG/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1812FG; Group: Washbasin faucets; Long Marketing: Washbasin faucet with Bidetta hand shower. Fixed spout and aerator. Shower hose 1.75 m, wall bracket. Lever is equipped with an eco-button for limiting water temperature and flow-rate, which can be bypassed by pressing the button. With flexible pipes.; Manufacturer: Oras; Market: INT;FIN;SWE;POL;EST;LTU;LVA;UKR; Model: 1812FG Washbasin faucet; Name_en: 1812FG Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Package Weight: 1.68 kg; Product Code: 1812FG; Product Datasheet: http://www.oras.com/datasheet/1812FG/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1812FG; Product URL: http://static.oras.com/1812FG; Type Name: 1812FG Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Flexible inlet pipes; Connection Size: G3/8; Eco Flow At 300kPa: 0.00317832 m3/s; Flow Rate At 300kPa: 0.00459091 m3/s; Installation and Maintenance: http://static.oras.com/manual/1812FG; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 195000 Pa; Spare Parts: http://static.oras.com/sp/1812FG; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1812FG(2018); Features: Single lever, Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1812FG; Name: 1812FG Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x145x150 mm / Hand shower: 45x65x285 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1812FG; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1812FG Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0721098 m2; Volume: 0.00193707 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1812FG(2018): 1812FG Washbasin faucet; Family and Type: 1812FG(2018): 1812FG Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1812FG(2018): 1812FG Washbasin faucet; Type Id: 1812FG(2018): 1812FG Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
